# Keil uVision project Cascade-inverter-control.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: measure_one_ch
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
    ./Function/Measure/: measure.c
    ./Function/Freq_up/: freq_up.c
    ./Function/Power_control/: power_control.c
    ./Function/PWM/: pwm.c
    ./Function/Data_transmit/: data_transmit.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
